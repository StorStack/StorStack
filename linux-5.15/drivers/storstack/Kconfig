## linux-5.15/drivers/storstack/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config STORSTACK
	tristate "StorStack kernel support"
	select NVME_CORE
```
